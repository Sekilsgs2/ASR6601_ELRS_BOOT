# Keil uVision project project.uvprojx, settings and files
target project (ARM-GNU)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(24000000) ESEL ELITTLE
  output: project +hex
  AfterMake: .\utils\genbinary.bat
  group platform
    ../../../../../platform/system/: system_cm4.c startup_cm4.S
  group drivers
    ../../../../../drivers/peripheral/src/: tremo_adc.c tremo_bstimer.c tremo_crc.c tremo_dac.c tremo_delay.c tremo_dma.c tremo_flash.c tremo_gpio.c tremo_i2c.c tremo_i2s.c tremo_iwdg.c tremo_lcd.c tremo_lptimer.c tremo_lpuart.c tremo_pwr.c tremo_rcc.c tremo_rtc.c tremo_spi.c tremo_system.c tremo_timer.c tremo_uart.c tremo_wdg.c
  group user
    ../../../../../projects/ASR6601CB-EVAL/examples/flash/data_program/src/: main.c tremo_it.c
    ./src/: flash.c irq.c stk500.c syscalls.c uart.c xmodem.c utilities.c frsky.c
